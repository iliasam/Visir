# IAR project STM32F4-Discovery.ewp, settings and files
configuration Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; STM32F40_41xxx; USE_USB_OTG_FS
  ICCARM.IExtraOptions: --diag_warning Pe191; --diag_suppress Pe191
  ICCARM.CCIncludePath2: ..\; ..\..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Display; ..\Mavlink; ..\Mavlink\mav_visir
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F4-Discovery.hex
  ILINK.IlinkOutputFile: STM32F4-Discovery_Demo.out
  ILINK.IlinkIcfFile: stm32f40x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Display
    ../Display/: lcd_worker.c lcd_worker.h ST7567A.c ST7567A.h visual_handling.c
  group EWARM
    ../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group Mavlink
    ../Mavlink/mav_visir/: mavlink.h
    ../Mavlink/: mavlink_handling.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ../: bluetooth_comm.c bno080_sensor.c bno080_sensor_parsing.c config.h fifo_functions.c hardware.c keys_controlling.c main.c power_controlling.c stm32f4xx_it.c system_stm32f4xx.c
